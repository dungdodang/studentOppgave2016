# Keil uVision project CANBus.uvprojx, settings and files
target CANBus Configuration (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.3.0
  cpu: IROM(0x00200000-0x002FFFFF) IRAM(0x20000000-0x2004FFFF) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: CANBus Configuration
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F746xx
  c misc: --C99
  c include: ../Inc;../Drivers/STM32F7xx_HAL_Driver/Inc;../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Include;../Drivers/CMSIS/Device/ST/STM32F7xx/Include;..\BSP\Components;..\BSP\Components\Common;..\BSP\STM32746G-Discovery;..\Utilities;..\Utilities\Log;..\Utilities\Fonts
  library: MicroLIB
  memory RVCT4: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  link misc: --diag_suppress=L6329
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F7xx/Source/Templates/: system_stm32f7xx.c
  group Application/User
    ../Src/: stm32f7xx_hal_msp.c main.c stm32f7xx_it.c
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_cortex.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal.c stm32f7xx_hal_flash.c stm32f7xx_hal_pwr.c stm32f7xx_hal_dma.c stm32f7xx_hal_can.c stm32f7xx_hal_uart.c stm32f7xx_ll_fmc.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_spi.c stm32f7xx_hal_adc.c stm32f7xx_hal_sdram.c stm32f7xx_hal_crc.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c
  group Application/MDK-ARM
    ../Drivers/CMSIS/Device/ST/STM32F7xx/Source/Templates/arm/: startup_stm32f746xx.s
  group Application/Utilities
    ../Utilities/Log/: lcd_log.c print_utils.c
  group Application/BSP
    ../BSP/STM32746G-Discovery/: stm32746g_discovery.c stm32746g_discovery_lcd.c stm32746g_discovery_sdram.c
  group Application/Configurations
    ../Inc/: instrument_configuration.h
software components: CMSIS:CORE 4.1.0
